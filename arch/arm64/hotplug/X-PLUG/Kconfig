## arch/arm64/hotplug/X-PLUG/Kconfig
```kconfig
config X_PLUG
	bool "Hotplugging of cores using a load array"
	help
	  This driver is intended for MSM8992 SOCs ONLY
```
